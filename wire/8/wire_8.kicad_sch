File: wire/8/wire_8.kicad_sch (KiCad schematic)
At the start: 2 parts, among them J1 Moat_Wire_8, J2 Moat_Wire_12

Commit message: A host of un-logged changes
Connections:
- no-connect marks 1 -> 3
